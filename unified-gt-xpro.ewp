# IAR project unified-gt-xpro.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1064xxx6A NXP MIMXRT1064xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_BOOT_HEADER_ENABLE=1; XIP_EXTERNAL_FLASH=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1064DVL6A; MIMXRT1064_SERIES; SDK_OS_FREE_RTOS
  ICCARM.CCIncludePath2: board; cmsis\m-profile; cmsis; components\exceptions; components\list; components\osa; components\uart; freertos\freertos_kernel; freertos\freertos_kernel\include; freertos\freertos_kernel\portable\iar\arm_cm4f; freertos\freertos_kernel\portable\memMang; freertos\freertos_kernel\template; include; include\common; include\avery; include\hobart; mimxrt1064\device; mimxrt1064\drivers; mimxrt1064\linker; mimxrt1064\periph; mimxrt1064\startup; source\printer; source\printer\common; source\printer\avery; source\printer\hobart; source\system; source\system\avery; source\system\common; source\system\hobart; source\system; source\system\avery; source\system\common; source\system\hobart; source\usb; source\valueMax; source\valueMax\avery; source\valueMax\common; source\valueMax\hobart; source\weigher; source\weigher\common; source\weigher\avery; source\weigher\hobart; utilities; utilities\avery; utilities\common; utilities\hobart; xip; source\usb\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MCUXPRESSO_SDK; CPU_MIMXRT1064DVL6A; MIMXRT1064_SERIES
  AARM.AUserIncludes: freertos\freertos_kernel\template
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: D:\Unified-Global-Firmware\UnifiedGTXproRT1064\mimxrt1064\linker\MIMXRT1064xxxxx_flexspi_nor.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group board
    board/: app.h board.c board.h clock_config.c clock_config.h hardware_init.c pin_mux.c pin_mux.h
  group cmsis
    cmsis/: cmsis_compiler.h cmsis_version.h core_cm7.h
  group cmsis/m-profile
    cmsis/m-profile/: armv7m_cachel1.h armv7m_mpu.h cmsis_iccarm_m.h
  group components/uart
    components/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group freertos/freertos_kernel
    freertos/freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/include
    freertos/freertos_kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h freertos_tasks_c_additions.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group freertos/freertos_kernel/portable/iar/arm_cm4f
    freertos/freertos_kernel/portable/iar/arm_cm4f/: port.c portasm.s portmacro.h
  group freertos/freertos_kernel/portable/memMang
    freertos/freertos_kernel/portable/memMang/: heap_4.c
  group freertos/freertos_kernel/template
    freertos/freertos_kernel/template/: FreeRTOSConfig.h FreeRTOSConfig_Gen.h
  group include/common
    include/common/: deviceProperties.h idleTask.h queueManager.h realtimeClock.h systemTimer.h threadManager.h
  group mimxrt1064/device
    mimxrt1064/device/: fsl_device_registers.h mcux_config.h MIMXRT1064.h MIMXRT1064_COMMON.h MIMXRT1064_features.h system_MIMXRT1064.c system_MIMXRT1064.h
  group mimxrt1064/drivers
    mimxrt1064/drivers/: fsl_adc.c fsl_adc.h fsl_adc_etc.c fsl_adc_etc.h fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_dcdc.c fsl_dcdc.h fsl_gpc.c fsl_gpc.h fsl_gpio.c fsl_gpio.h fsl_gpt.c fsl_gpt.h fsl_iomuxc.h fsl_lpuart.c fsl_lpuart.h fsl_pmu.c fsl_pmu.h fsl_snvs_hp.c fsl_snvs_hp.h fsl_src.c fsl_src.h
  group mimxrt1064/linker
    mimxrt1064/linker/: MIMXRT1064xxxxx_flexspi_nor.icf MIMXRT1064xxxxx_ram.icf MIMXRT1064xxxxx_sdram.icf
  group mimxrt1064/periph
    mimxrt1064/periph/: PERI_ADC.h PERI_ADC_ETC.h PERI_AIPSTZ.h PERI_AOI.h PERI_BEE.h PERI_CAN.h PERI_CCM.h PERI_CCM_ANALOG.h PERI_CM7_MCM.h PERI_CMP.h PERI_CSI.h PERI_CSU.h PERI_DCDC.h PERI_DCP.h PERI_DMA.h PERI_DMAMUX.h PERI_ENC.h PERI_ENET.h PERI_EWM.h PERI_FLEXIO.h PERI_FLEXRAM.h PERI_FLEXSPI.h PERI_GPC.h PERI_GPIO.h PERI_GPT.h PERI_I2S.h PERI_IOMUXC.h PERI_IOMUXC_GPR.h PERI_IOMUXC_SNVS.h PERI_IOMUXC_SNVS_GPR.h PERI_KPP.h PERI_LCDIF.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPUART.h PERI_OCOTP.h PERI_PGC.h PERI_PIT.h PERI_PMU.h PERI_PWM.h PERI_PXP.h PERI_ROMC.h PERI_RTWDOG.h PERI_SEMC.h PERI_SNVS.h PERI_SPDIF.h PERI_SRC.h PERI_TEMPMON.h PERI_TMR.h PERI_TRNG.h PERI_TSC.h PERI_USB.h PERI_USB_ANALOG.h PERI_USBNC.h PERI_USBPHY.h PERI_USDHC.h PERI_WDOG.h PERI_XBARA.h PERI_XBARB.h PERI_XTALOSC24M.h
  group mimxrt1064/startup
    mimxrt1064/startup/: startup_MIMXRT1064.s
  group source
    source/: unifiedScale.c
  group source/common
    source/system/common/: idleTask.c queueManager.c realtimeClock.c systemTimer.c threadManager.c
  group source/usb/include
    source/usb/include/: usb.h usb_misc.h usb_spec.h
  group utilities/common
    utilities/common/: fsl_assert.c fsl_assert.h fsl_debug_console.c fsl_debug_console.h fsl_str.c fsl_str.h
  group xip
    xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
